# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: st7735 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable;.\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\FreeRTOS\Source\portable\MemMang
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h MyDMA.c MyRTC.c MyRTC.h
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h PWM.c Serial.c Font.h GUI.c GUI.h LCD_Config.h Lcd_Driver.c Lcd_Driver.h Picture.h AD.c AD.h MyI2C.c MyI2C.h MPU6050.c MPU6050.h MySPI.c MySPI.h W25Q32.c W25Q32.h W25Q32_Ins.h Serial.h esp_uart.c esp_at.c esp_at.h esp_uart.h MPU6050_Reg.c MPU6050_Reg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h weatherapi.c weatherapi.h weather_icons.c weather_icons.h icon_weather_duoyun.c icon_weather_feng.c icon_weather_qing.c icon_weather_xue.c icon_weather_yin.c icon_weather_yu.c
  group FreeRTOS
    ./FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
